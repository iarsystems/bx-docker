# IAR project c-stat.ewp, settings and files
configuration Debug (RH850, debug)
  General.GDeviceSelect: UnspecifiedG3M RH850 G3M - Unspecified
  ICCRH850.IccLang: 0
  ICCRH850.CCOptLevel: 1
  ICCRH850.CCOptStrategy: 0
  ILINK.IlinkOutputFile: c-stat.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (RH850)
  as the first configuration, except:
  ICCRH850.CCOptLevel: 3
  ICCRH850.CCDefines: NDEBUG
  group (top)
    ../common/: c-stat1.c c-stat2.c
