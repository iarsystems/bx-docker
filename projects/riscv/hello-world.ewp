# IAR project hello-world.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: RV32 RV32
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCDefines: NDEBUG
  group (top)
    ../common/: c-stat1.c c-stat2.c
